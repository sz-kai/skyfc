# Keil uVision project SkyFC-FMU.uvprojx, settings and files
target SkyFC-FMU (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: SkyFC-FMU
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STM324x7I_EVAL,STM32F427_437xx,USE_STDPERIPH_DRIVER
  c include: ..\00_Libraries\CMSIS;..\00_Libraries\STM32F10x_StdPeriph_Driver\inc;..\01_Middlewares\FatFs;..\01_Middlewares\FreeRTOS\include;..\01_Middlewares\FreeRTOS\portable\RVDS\ARM_CM3;..\01_Middlewares\Mavlink\common;..\01_Middlewares\Mavlink;..\02_Common\COMMON;..\02_Common\RINGBUFFER;..\03_BSP\DMA;..\03_BSP\EXTI;..\03_BSP\IIC_SW;..\03_BSP\SPI;..\03_BSP\SYS;..\03_BSP\SYSTICK;..\03_BSP\TIM;..\03_BSP\USART;..\03_BSP\Flash;..\03_BSP\SDIO;..\04_Driver\MPU6000;..\04_Driver\MS5611;..\04_Driver\NEO_M8N;..\04_Driver\HMC5883;..\05_Communication\Mavlink;..\05_Communication\SBUS;..\05_Communication\UBX;..\05_Communication\IC_COMM;..\06_Application\00_Algorithm;..\06_Application\01_Sensor_Processing;..\06_Application\02_Navigation;..\06_Application\03_Guidance;..\06_Application\04_Control;..\06_Application\05_Task;..\07_User;.cmsis\include;RTE\_Drone_F427
  asm define: USE_STM324x7I_EVAL,STM32F427_437xx,USE_STDPERIPH_DRIVER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group 08_User
    ../07_User/: main.c stm32f4xx_it.c pro_config.h pro_include.h
  group 07_Application/06_Task
    ../06_Application/05_Task/: task_datalog.c task_integrated_navigation.c task_sensor.c task_ioc.c task_guidance.c task_control.c
  group 07_Application/05_Control
    ../06_Application/04_Control/: attitude_control.c position_control.c
  group 07_Application/03_Guidance
    ../06_Application/03_Guidance/: guidance.c rc_mapper.c
  group 07_Application/04_Navigation
    ../06_Application/02_Navigation/: attitude_estimate.c position_estimate.c
  group 07_Application/02_Sensor_Processing
    ../06_Application/01_Sensor_Processing/: imu_processing.c mag_processing.c baro_processing.c
  group 07_Application/01_Algorithm
    ../06_Application/00_Algorithm/: mahony.c pid.c filter.c
  group 06_Communication
    ../05_Communication/Mavlink/: mavlink_handle.c
    ../05_Communication/IC_COMM/: ioc_protocol.c
  group 05_Drivers
    ../04_Driver/MPU6000/: bsp_mpu6000.c
    ../04_Driver/NEO_M8N/: gps.c ubx.c
    ../04_Driver/HMC5883/: hmc5883l.c
    ../04_Driver/MS5611/: ms5611.c ms5611_port.c
  group 04_Peripherals
    ../03_BSP/DMA/: bsp_dma.c
    ../03_BSP/EXTI/: bsp_exti.c
    ../03_BSP/IIC_SW/: i2c_sw.c
    ../03_BSP/SPI/: bsp_spi.c
    ../03_BSP/SYS/: bsp_sys.c
    ../03_BSP/SYSTICK/: bsp_systick.c
    ../03_BSP/TIM/: bsp_tim.c
    ../03_BSP/USART/: bsp_usart.c
    ../03_BSP/SDIO/: bsp_sdio_sd.c
    ../03_BSP/Flash/: bsp_flash.c
  group 03_Common
    ../02_Common/RINGBUFFER/: ringbuff.c
    ../02_Common/COMMON/: com_data.c pro_common.c com_type.h
  group 02_Middlewares/FatFs
    ../01_Middlewares/FatFs/: diskio.c diskio.h ff.c ff.h ffconf.h ffsystem.c ffunicode.c
  group 01_Libraries/STM32F4xx_StdPeriph_Driver
    ../00_Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group 00_CMSIS_Startup
    ../00_Libraries/CMSIS/: system_stm32f4xx.c startup_stm32f427_437xx.s
